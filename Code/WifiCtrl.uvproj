# Keil uVision project WifiCtrl.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: WifiCtrl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\drv\delay;.\drv\gpio;.\drv\uart;.\drv\pwm;D:\WifiCtrl
  group main
    ./: main.c
  group drv
    ./drv/delay/: delay.c
    ./drv/gpio/: GPIO.c
    ./drv/uart/: UART.C
    ./drv/pwm/: PWM.C
